## techpack/Kconfig
```kconfig
menu "Tech packages"

source "techpack/data/Kconfig"

source "techpack/mi845/Kconfig"

endmenu
```
